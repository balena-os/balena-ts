# ts4900
SUPERVISOR_REPOSITORY_ts4900 = "resin/armv7hf-supervisor"

# ts7700
SUPERVISOR_REPOSITORY_ts7700 = "resin/armel-supervisor"
